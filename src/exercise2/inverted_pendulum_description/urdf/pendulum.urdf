Commit message: Preliminary shared data object refactor

File: src/exercise2/inverted_pendulum_description/urdf/pendulum.urdf (robot description, URDF)
Before this commit: robot pendulum, 3 links, 2 joints
Joints:
- joint joint_1: axis 0 0 1 -> 1 0 0
